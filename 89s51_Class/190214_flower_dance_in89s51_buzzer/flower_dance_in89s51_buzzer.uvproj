# Keil uVision project flower_dance_in89s51_buzzer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: flower_dance_in89s51_buzzer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 flower_dance_in89s51_buzzer.c
