# Keil uVision project interrupter_button_control_7seg.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: interrupter_button_control_7seg +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: interrupter_button_control_7seg.c
